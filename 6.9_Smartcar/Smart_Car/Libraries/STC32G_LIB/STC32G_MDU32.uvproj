# Keil uVision project STC32G_MDU32.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: STC32G_MDU32 (library)
  group Source Group 1
    ./src/: FPADD_SUB.A51 FPADD_SUB_HUGE.A51 FPMUL.A51 FPMUL_HUGE.A51 FPDIV.A51 FPDIV_HUGE.A51 FPGETOPN2.A51 FPGETOPN2_HUGE.A51 LMUL.a51 LMUL_HUGE.a51 ULDIV.a51 ULDIV_HUGE.a51 SLDIV.a51 SLDIV_HUGE.a51 LADD64.A51 LADD64_HUGE.A51 LSUB64.A51 LSUB64_HUGE.A51 LMUL64.A51 LMUL64_HUGE.A51 ULDIV64.A51 ULDIV64_HUGE.A51 SLDIV64.A51 SLDIV64_HUGE.A51 CABS.a51 CABS_HUGE.a51 ABS.a51 ABS_HUGE.a51 LABS.a51 LABS_HUGE.a51 FABS.a51 FABS_HUGE.a51
